IMAGE_INSTALL:append = " mqtt-cmd-client"

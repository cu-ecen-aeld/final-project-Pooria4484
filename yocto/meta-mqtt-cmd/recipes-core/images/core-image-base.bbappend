IMAGE_INSTALL:append = " aesdsocket aesdchar mqtt-cmd-client"
